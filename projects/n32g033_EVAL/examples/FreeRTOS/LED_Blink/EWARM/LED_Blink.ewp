# IAR project LED_Blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G033x8 Nations N32G033x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G033; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\bsp\inc; ..\..\..\..\..\..\firmware\n32g033_std_periph_driver\inc; ..\..\..\..\..\..\Middlewares\freertos\portable\MemMang; ..\..\..\..\..\..\Middlewares\freertos\portable\IAR\ARM_CM0; ..\..\..\..\..\..\Middlewares\freertos\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\..\..\..\Middlewares\freertos\include
  OBJCOPY.OOCOutputFile: LED_Blink.bin
  ILINK.IlinkOutputFile: LED_Blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g033.c
  group DOC
    ../src/: readme.txt
  group FreeRTOS
    ../../../../../../Middlewares/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/freertos/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/freertos/portable/IAR/ARM_CM0/: port.c portasm.s
  group FWLB
    ../../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_gpio.c n32g033_rcc.c n32g033_tim.c n32g033_uart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g033_EWARM.S
  group USER
    ../src/: led.c main.c n32g033_it.c timer.c
