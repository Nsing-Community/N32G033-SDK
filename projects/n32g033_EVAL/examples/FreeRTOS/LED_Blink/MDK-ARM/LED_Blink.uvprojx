# Keil uVision project LED_Blink.uvprojx, settings and files
target N32G033 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G033K8 Nationstech
  pack: Nationstech.N32G033_DFP.0.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED_Blink +hex
  AfterMake: fromelf --bin --output=.\bin\LED_Blink.bin .\Objects\LED_Blink.axf
  AfterMake: .\Keil5_disp_size_bar_v0.3.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32G033, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g033_std_periph_driver\inc;..\..\..\..\..\..\Middlewares\freertos\include;..\..\..\..\..\..\Middlewares\freertos\portable\RVDS\ARM_CM0;..\..\..\..\..\..\Middlewares\freertos\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g033.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g033.c
  group FWLB
    ../../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_gpio.c n32g033_rcc.c n32g033_uart.c n32g033_tim.c
  group FreeRTOS
    ../../../../../../Middlewares/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/freertos/portable/RVDS/ARM_CM0/: port.c
    ../../../../../../Middlewares/freertos/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/freertos/include/: FreeRTOSConfig.h
  group BSP
    ../../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32g033_it.c led.c timer.c
  group DOC
    ../: readme.txt
