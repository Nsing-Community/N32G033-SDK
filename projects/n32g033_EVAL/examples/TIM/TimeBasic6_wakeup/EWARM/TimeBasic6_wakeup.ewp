# IAR project TimeBasic6_wakeup.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G033x8 Nsing N32G033x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G033; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g033_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\1.work\1.nationz\NS3616\SVN\V1.1.0\6-Software_Development_Kit\Nsing.N32G033_Library.1.1.0\firmware\CMSIS\device\startup; D:\1.work\1.nationz\NS3616\SVN\V1.1.0\6-Software_Development_Kit\Nsing.N32G033_Library.1.1.0\firmware\CMSIS\core; D:\1.work\1.nationz\NS3616\SVN\V1.1.0\6-Software_Development_Kit\Nsing.N32G033_Library.1.1.0\firmware\CMSIS\device; D:\1.work\1.nationz\NS3616\SVN\V1.1.0\6-Software_Development_Kit\Nsing.N32G033_Library.1.1.0\firmware\n32g033_std_periph_driver\inc; D:\1.work\1.nationz\NS3616\SVN\V1.1.0\6-Software_Development_Kit\Nsing.N32G033_Library.1.1.0\projects\n32g033_EVAL\bsp\inc; D:\1.work\1.nationz\NS3616\SVN\V1.1.0\6-Software_Development_Kit\Nsing.N32G033_Library.1.1.0\projects\n32g033_EVAL\examples\TIM\TimeBasic6_wakeup\inc
  OBJCOPY.OOCOutputFile: TimeBasic6_wakeup.bin
  ILINK.IlinkOutputFile: TimeBasic6_wakeup.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: delay.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g033.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_exti.c n32g033_flash.c n32g033_gpio.c n32g033_pwr.c n32g033_rcc.c n32g033_tim.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g033_EWARM.S
  group USER
    ../src/: main.c n32g033_it.c
