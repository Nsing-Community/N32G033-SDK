# IAR project WakeUpFromStop.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G033x8 Nsing N32G033x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G033; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g033_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WakeUpFromStop.bin
  ILINK.IlinkOutputFile: WakeUpFromStop.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g033.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_dma.c n32g033_exti.c n32g033_flash.c n32g033_gpio.c n32g033_pwr.c n32g033_rcc.c n32g033_uart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g033_EWARM.S
  group USER
    ../src/: main.c n32g033_it.c
