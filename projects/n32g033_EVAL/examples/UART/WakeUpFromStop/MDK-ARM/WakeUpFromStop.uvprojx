# Keil uVision project WakeUpFromStop.uvprojx, settings and files
target N32G033 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G033K8 Nsingtech
  pack: Nsingtech.N32G033_DFP.0.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WakeUpFromStop +hex
  AfterMake: fromelf --bin --output=.\bin\WakeUpFromStop.bin .\Objects\WakeUpFromStop.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G033, USE_STDPERIPH_DRIVER,SYSCLK_FREQ = LSI_VALUE
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g033_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g033.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g033.c
  group FWLB
    ../../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_gpio.c n32g033_rcc.c n32g033_uart.c n32g033_dma.c n32g033_pwr.c n32g033_flash.c n32g033_exti.c
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group USER
    ../src/: main.c n32g033_it.c
  group DOC
    ../: readme.txt
