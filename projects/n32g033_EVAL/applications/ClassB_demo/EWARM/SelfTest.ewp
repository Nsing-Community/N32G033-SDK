# IAR project SelfTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G033x8 Nsing N32G033x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G033; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\firmware\n32g033_std_periph_driver\inc; ..\..\..\..\..\Middlewares\N32_SelfTest_Library\inc; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SelfTest.bin
  ILINK.IlinkOutputFile: SelfTest.out
  ILINK.IlinkIcfFile: SelfTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../firmware/CMSIS/device/startup/: startup_n32g033_EWARM_ClassB.S
    ../../../../../firmware/CMSIS/device/: system_n32g033.c
  group FWLB
    ../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_dbg.c n32g033_flash.c n32g033_gpio.c n32g033_iwdg.c n32g033_pwr.c n32g033_rcc.c n32g033_uart.c
  group SelfTest_Assem
    ../../../../../Middlewares/N32_SelfTest_Library/assem/: n32_cm0_STLcpurunIAR.s n32_cm0_STLcpustartIAR.s n32_cm0_STLRamMcMxIAR.s
  group SelfTest_Library
    ../../../../../Middlewares/N32_SelfTest_Library/src/: n32_cm0_STLclock.c n32_cm0_STLcrc32.c n32_cm0_STLmain.c n32_cm0_STLstartup.c n32_cm0_STLtranspRam.c
  group USER
    ../: crc32_software.c main.c n32_cm0_it.c
