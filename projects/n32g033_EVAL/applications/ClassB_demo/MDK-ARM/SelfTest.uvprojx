# Keil uVision project SelfTest.uvprojx, settings and files
target STL_N32G033 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G033K8 Nsingtech
  pack: Nsingtech.N32G033_DFP.0.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SelfTest +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: srecord_crc32.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: N32G033,USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\n32g033_std_periph_driver\inc;..\..\..\..\..\Middlewares\N32_SelfTest_Library\inc;..\..\ClassB_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\SelfTest_N32G033.sct
  group User
    ../: main.c n32_cm0_it.c crc32_software.c
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_n32g033.c
    ../../../../../firmware/CMSIS/device/startup/: startup_n32g033.s
  group SelfTest_Assem
    ../../../../../Middlewares/N32_SelfTest_Library/assem/: n32_cm0_STLcpurunKEIL.s n32_cm0_STLcpustartKEIL.s n32_cm0_STLRamMcMxKEIL.s
  group SelfTest_Library
    ../../../../../Middlewares/N32_SelfTest_Library/src/: n32_cm0_STLclock.c n32_cm0_STLcrc32.c n32_cm0_STLmain.c n32_cm0_STLstartup.c n32_cm0_STLtranspRam.c
  group N32G033_Periph
    ../../../../../firmware/n32g033_std_periph_driver/src/: misc.c n32g033_dbg.c n32g033_flash.c n32g033_gpio.c n32g033_iwdg.c n32g033_rcc.c n32g033_uart.c n32g033_pwr.c
